# Keil uVision project my_first.uvprojx, settings and files
target STM32F303 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uRLC_1_0_62 +hex
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM4, STM32F30X, USE_STM32303C_EVAL
  c include: .\STM32F30x_StdPeriph_Driver;.\STM32F30x_StdPeriph_Driver\inc;.\STM32F30x_StdPeriph_Driver\src;.\STM32F30x_StdPeriph_Driver\CMSIS;.\STM32F30x_StdPeriph_Driver\CMSIS\Include;.\STM32F30x_StdPeriph_Driver\CMSIS\Source;.\inc;.\src;.\Libraries;.\Libraries\i2cm;.\Libraries\spim;.\Libraries\ssd1306;.\Libraries\display;.\Libraries\display\fonts;.\Libraries\gpio;.\Libraries\EEPROM_Emulation;.\Libraries\usb;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\src;.\Libraries\Parser
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\oscil_stm32f303.sct
  group SPL
    ./STM32F30x_StdPeriph_Driver/inc/: stm32f30x_adc.h stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_fmc.h stm32f30x_gpio.h stm32f30x_hrtim.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h
    ./STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group CMSIS
    ./inc/: stm32f30x_it.h stm32f30x_conf.h
    ./src/: system_stm32f30x.c stm32f30x_it.c
    ./STM32F30x_StdPeriph_Driver/CMSIS/Include/: stm32f30x.h system_stm32f30x.h
    ./STM32F30x_StdPeriph_Driver/CMSIS/Source/: startup_stm32f303xe.s
    ./STM32F30x_StdPeriph_Driver/CMSIS/: stm32f30x_conf.h stm32f30x_it.h
  group mane
    ./src/: main.c process_measure.c corrector.c calc_rc.c calc.c
    ./inc/: main.h process_measure.h corrector.h calc_rc.h
  group lcd
    ./src/: number_edit.c format_print.c lcd_interface.c menu.c
    ./inc/: number_edit.h format_print.h lcd_interface.h menu.h
    ./Libraries/ssd1306/: lcd.c lcd.h segoe16.c segoe16.h fonts.c fonts.h ssd1306.c ssd1306.h
  group hardware
    ./src/: quadrature_encoder.c systick.c dac.c adc.c vbat.c mcp6s21.c
    ./inc/: quadrature_encoder.h systick.h dac.h adc.h vbat.h mcp6s21.h types.h
    ./Libraries/gpio/: gpio.c gpio.h
  group i2c
    ./Libraries/i2cm/: i2cSoft.c i2cSoft.h
  group spi
    ./Libraries/spim/: spim.c spim.h
  group eeprom
    ./Libraries/EEPROM_Emulation/: eeprom.c eeprom.h
  group usb
    ./Libraries/usb/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h hw_config.h
  group usb_core
    ./Libraries/STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group parser
    ./Libraries/Parser/: parser.h parser.c
